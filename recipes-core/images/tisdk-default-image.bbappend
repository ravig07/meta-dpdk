PR_append = ".tisdk2"

IMAGE_INSTALL_append += "\
    dpdk \
    dpdk-module \
    dperf \
"
